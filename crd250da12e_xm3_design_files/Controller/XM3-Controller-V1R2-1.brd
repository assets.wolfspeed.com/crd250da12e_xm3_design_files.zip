# Allegro board XM3-Controller-V1R2-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N96795: length 9.8
  TOP w0.254: RT132.1 RT131.1 260.39,23.45 257.39,23.45 256.64,24.21 UT31.13
  TOP w0.381: RT132.1 265.26,24.15 UT30.3
N97055: length 27.7
  TOP w0.178: QT1.1 260.69,20.45 ; QT1.1 259.61,19.89 ; QT1.1 260.69,19.34 ; QT1.1 259.62,20.45 ; QT1.1 260.15,19.34 ; QT1.1 260.7,19.89 ; QT1.1 260.15,20.45 ; QT1.1 259.62,19.34 ; QT1.2 260.69,19.18 ; QT1.2 260.69,18.07 ; QT1.2 260.15,18.07 ; QT1.2 259.62,18.07 ; QT1.2 259.62,19.18 ; QT1.2 260.15,19.18 ; QT1.2 259.61,18.62 ; QT1.2 260.7,18.62 ; QT1.3 260.7,17.35 ; QT1.3 260.15,17.91 ; QT1.3 259.61,17.35 ; QT1.3 259.62,17.91 ; QT1.3 260.69,17.91
  TOP w0.254: RT129.2 252.44,28.69 v1(252.6,28.53)
  LAYER3 w0.508: v1(252.6,28.53) 253.24,28.53 257.05,24.72 257.05,19.89 v1(258.44,18.49)
N97211: length 3.7
  TOP w0.254: UT31.2 251.1,25.21 250.35,25.95 RT130.1
  TOP w0.508: RT130.1 CT79.2
N97283: length 1.4
  TOP w0.508: CT75.1 249.68,28.74 RT130.2
N139937: length 1.5
  TOP w0.635: RT9.1 RT10.2
N139941: length 1.5
  TOP w0.635: RT8.1 RT9.2
N139945: length 1.5
  TOP w0.635: RT7.1 RT8.2
N139949: length 1.5
  TOP w0.635: RT6.1 RT7.2
N139953: length 1.5
  TOP w0.635: RT5.1 RT6.2
N140053: length 1.5
  BOTTOM w0.635: RB2.1 RB1.2
N140057: length 1.5
  BOTTOM w0.635: RB3.1 RB2.2
N140061: length 1.5
  BOTTOM w0.635: RB4.1 RB3.2
N140065: length 1.5
  BOTTOM w0.635: RB5.1 RB4.2
N140069: length 1.5
  BOTTOM w0.635: RB6.1 RB5.2
N141814: length 1.5
  BOTTOM w0.635: CB17.1 194.42,74.9 RB19.2
N143941: length 1.5
  BOTTOM w0.635: RB20.2 144.89,74.39 CB18.1
N145779: length 2.8
  TOP w0.508: UT28.1 229.86,37.59 229.78,37.52 ; 229.78,37.52 CT69.1 ; 229.78,37.52 RT115.2
N146352: length 2.8
  TOP w0.508: 266.17,27.6 CT77.1 ; 266.17,27.6 266.24,27.52 UT30.1 ; 266.17,27.6 RT127.2
N147166: length 31.7
  TOP w0.178: QT3.3 33.3,4.91 ; QT3.3 32.22,4.35 ; QT3.3 32.22,3.8 ; QT3.3 32.76,3.8 ; QT3.3 32.22,4.91 ; QT3.3 33.3,4.35 ; QT3.3 33.3,3.8 ; QT3.3 32.76,4.91 ; 32.22,6.18 QT3.2 ; QT3.2 33.3,6.18 ; QT3.2 32.22,5.07 ; QT3.2 32.22,5.62 ; QT3.2 33.3,5.62 ; QT3.2 32.76,5.07 ; QT3.2 32.76,6.18 ; QT3.2 33.3,5.07 ; 29.69,5.62 QT2.3 ; QT2.3 30.23,5.07 ; QT2.3 30.23,6.18 ; QT2.3 30.77,5.62 ; QT2.3 30.77,6.18 ; QT2.3 29.69,5.07 ; QT2.3 30.77,5.07 ; QT2.3 29.69,6.18 ; 30.23,2.53 QT2.1 ; QT2.1 30.23,3.64 ; QT2.1 30.77,3.64 ; QT2.1 30.77,3.08 ; QT2.1 29.69,3.08 ; QT2.1 29.69,3.64 ; QT2.1 30.77,2.53 ; QT2.1 29.69,2.53 ; 29.69,4.35 QT2.2 ; QT2.2 30.77,4.91 ; QT2.2 30.77,4.35 ; QT2.2 29.69,3.8 ; QT2.2 30.77,3.8 ; QT2.2 30.23,4.91 ; QT2.2 30.23,3.8 ; QT2.2 29.69,4.91 ; 32.76,6.34 QT3.1 ; QT3.1 33.3,6.89 ; QT3.1 33.3,7.45 ; QT3.1 32.76,7.45 ; QT3.1 33.3,6.34 ; QT3.1 32.22,6.89 ; QT3.1 32.22,6.34 ; QT3.1 32.22,7.45
N148075: length 18.2
  TOP w0.254: RT139.2 33.88,11.89 33.59,11.59 UT32.10 33.06,11.61 v1(31.85,11.61)
  TOP w0.635: QT2.4 30.23,7.85 30.86,8.49 v1(31.3,8.49) ; QT3.4 v1(32.76,1.52)
  LAYER3 w0.635: v1(31.85,11.61) 31.85,9.03 v1(31.3,8.49) 32.76,7.03 v1(32.76,1.52)
N148197: length 1.4
  TOP w0.254: RT139.1 CT87.1
N148540: length 39.9
  TOP w0.178: 38.23,2.53 QT3.5 ; QT3.5 37.69,3.64 ; QT3.5 38.77,3.64 ; QT3.5 37.69,2.53 ; QT3.5 38.77,3.08 ; QT3.5 38.77,2.53 ; QT3.5 38.23,3.64 ; QT3.5 37.69,3.08 ; QT3.6 38.77,4.91 ; QT3.6 37.69,3.8 ; QT3.6 37.69,4.35 ; QT3.6 38.77,3.8 ; QT3.6 38.23,4.91 ; QT3.6 37.69,4.91 ; QT3.6 38.77,4.35 ; QT3.6 38.23,3.8 ; QT3.8 38.77,7.45 ; QT3.8 38.77,6.89 ; QT3.8 37.69,6.89 ; QT3.8 37.69,6.34 ; QT3.8 38.77,6.34 ; QT3.8 38.23,6.34 ; QT3.8 38.23,7.45 ; QT3.8 37.69,7.45 ; QT3.7 38.77,5.62 ; QT3.7 38.23,6.18 ; QT3.7 38.77,5.07 ; QT3.7 38.77,6.18 ; QT3.7 37.69,5.07 ; QT3.7 38.23,5.07 ; QT3.7 37.69,6.18 ; QT3.7 37.69,5.62
  TOP w0.254: 37.34,9.86 37.35,9.87 37.35,10.27 36.53,11.09 UT32.9
  TOP w0.559: RT141.1 39.01,9.59 ; RT141.1 35.15,8.17 ; RT141.1 35.15,9.59 ; RT141.1 39.01,8.17 ; RT141.1 37.08,9.74 ; RT141.1 35.15,8.88 ; RT141.1 37.08,8.03 ; RT141.1 39.01,8.88
N149103: length 13.1
  TOP w0.254: RT144.2 24.41,8.93 v1(23.3,8.93) ; UT32.6 30.54,9.56 29.4,8.42 27.64,8.42 v1(27.57,8.34)
  TOP w0.635: RT144.2 RT143.1
  LAYER3 w0.254: v1(27.57,8.34) 26.99,8.93 v1(23.3,8.93)
N149107: length 4.1
  TOP w0.254: UT32.2 26.99,11.09 26.48,11.59 RT142.1
  TOP w0.635: RT143.2 RT142.1
N149113: length 8.6
  TOP w0.254: v1(27.37,10.32) 27.62,10.58 UT32.3 ; v1(23.3,11.34) 24.28,11.34 RT142.2
  TOP w0.635: RT142.2 RT140.1
  LAYER3 w0.254: v1(27.37,10.32) 25.74,10.32 24.72,11.34 v1(23.3,11.34)
N149983: length 4.6
  TOP w0.254: CT88.1 30.03,11.96 30.03,10.7 29.4,10.07 UT32.4
N150621: length 4.4
  TOP w0.254: UT32.7 32.19,10.07 30.67,11.59 RT136.2
N177905: length 2.2
  TOP w0.508: DT7.1 149.28,37.61 RT119.2
N177925: length 36.4
  TOP w0.508: DT7.2 149.22,41.86 145.16,45.93 122.65,45.93 UT21.3 121.99,46.39 120.9,45.3 DT6.2
N178332: length 2.5
  TOP w0.508: DT6.1 RT116.2
N179044: length 2.8
  TOP w0.508: UT21.1 123.13,49.73 123.05,49.8 ; CT59.1 123.05,49.8 ; 123.05,49.8 RT108.2
N203219: length 2.3
  TOP w0.254: UT31.4 251.07,24.21 250.98,24.11 250.32,24.11 249.85,24.59 RT133.2
N205443: length 28.9
  TOP w0.178: RT135.2 258.54,15.13 ; RT135.2 257.08,15.79 ; RT135.2 258.54,16.45 ; RT135.2 257.08,15.13 ; RT135.2 257.81,16.47 ; RT135.2 257.08,16.45 ; RT135.2 257.81,15.11 ; RT135.2 258.54,15.79 ; DT10.C 256.41,16.35 ; DT10.C 256.9,15.05 ; DT10.C 256.9,16.35 ; DT10.C 255.92,15.05 ; DT10.C 256.41,15.05 ; DT10.C 256.96,15.7 ; DT10.C 255.92,16.35 ; 259.62,15.53 QT1.4 ; QT1.4 260.69,15.53 ; QT1.4 260.15,15.53 ; QT1.4 259.61,16.08 ; QT1.4 260.7,16.08
  TOP w0.254: v1(250.7,24.72) 250.82,24.72 250.83,24.72 251.08,24.72 251.09,24.71 UT31.3
  LAYER3 w0.508: v1(250.7,24.72) 250.7,22.94 256.92,16.72 258.57,16.72 v1(259.08,16.21)
N273504: length 15.1
  TOP w0.254: UT14.5 105.32,71.1
  TOP w0.381: RT84.2 105.92,70.37 ; RT84.2 105.92,74.63 104.52,76.02 101.98,76.02 101.34,76.66 101.34,79.13 101.64,79.43 RT41.1 ; RT84.2 105.32,71.1
N273798: length 1.8
  TOP w0.254: UT14.6 103.88,71.8 CT40.2
N273802: length 3
  TOP w0.254: UT14.7 103.38,72.3 CT40.1
  TOP w0.381: RT69.2 CT40.1
N275299: length 15.1
  TOP w0.254: UT15.5 111.92,71.1
  TOP w0.381: 111.92,71.1 RT85.2 112.52,75.01 111.5,76.02 108.58,76.02 107.95,76.66 107.95,79.05 108.33,79.43 RT43.1
N275399: length 3
  TOP w0.254: CT41.1 109.98,72.3 UT15.7
  TOP w0.381: RT70.2 CT41.1
N275407: length 1.8
  TOP w0.254: CT41.2 110.49,71.8 UT15.6
N275841: length 15
  TOP w0.254: UT16.5 118.53,71.1
  TOP w0.381: RT45.1 115.56,79.44 114.82,79.44 114.55,79.17 114.55,76.79 115.31,76.02 117.98,76.02 119.12,74.88 RT86.2 118.53,71.1
N275941: length 3
  TOP w0.254: CT42.1 116.58,72.3 UT16.7
  TOP w0.381: RT71.2 CT42.1
N275949: length 1.8
  TOP w0.254: CT42.2 117.09,71.8 UT16.6

## Copper pours and planes (outline as drawn)
+3V3 on PWR: 24.64,53.16 26.43,53.91 27.18,55.7 27.18,68.4 24.64,68.4 24.64,72.47 27.18,72.47 27.18,91.52 26.43,93.32 24.64,94.06 16.67,94.06 14.87,94.8 14.13,96.6 14.13,100 15.78,103.97 19.75,105.62 194.44,105.62 196.23,104.87 196.98,103.08 196.98,60.19 197.17,59.21 197.72,58.39 201.19,54.92 202.01,54.37 202.98,54.18 219.29,54.18 220.26,53.99 221.09,53.44 242.71,31.81 243.54,31.26 244.51,31.07 267.08,31.07 268.88,30.32 269.62,28.53 269.62,6 267.97,2.03 264,0.38 225.54,0.38 221.57,2.03 219.92,6 219.92,12 218.05,16.51 213.54,18.38 56.46,18.38 51.95,16.51 50.08,12 50.08,6 48.43,2.03 44.46,0.38 2.54,0.38 1.01,1.01 0.38,2.54 0.38,50.62 1.12,52.42 2.92,53.16
+5V on TOP: 87.25,78.44 83.44,78.44 83.44,93.17 86.49,93.17 86.49,96.6 79.5,96.6 79.5,75.77 87.25,75.77
+5V on BOTTOM: 50.42,43.64 79.5,43.64 79.5,78.44 87.25,78.44 87.25,75.77 83.44,75.77 83.44,63.07 87.12,63.07 87.12,60.53 83.44,60.53 83.44,43.64 116.08,43.64 117.73,41.99 117.73,37.16 117.6,37.04 50.42,37.04
+5V-ISO on PWR: 18.67,90.68 20.46,89.94 21.21,88.14 21.21,60.2 20.46,58.4 18.67,57.66 2.92,57.66 1.12,58.4 0.38,60.2 0.38,88.14 1.12,89.94 2.92,90.68
+12V on TOP (solid shape): 228.09,28.04 231.01,28.04 231.01,27.74 229.36,27.74 229.36,23.19 226.26,23.19 226.26,19.81 226.41,19.66 237.18,19.66 237.18,21.69 240.69,21.69 240.69,17.58 226.57,17.58 223.65,20.5 223.65,25.45 224.03,25.83 226.57,25.83 226.57,29.37 228.09,29.37
+12V on TOP (solid shape): 248.96,25.09 248.96,24.09 248.96,24.07 248.97,24.03 248.99,24 249.01,23.97 249.04,23.94 249.07,23.93 249.11,23.91 249.15,23.9 249.17,23.89 249.17,23.85 250.16,23.85 250.2,23.83 250.25,23.82 250.3,23.81 250.32,23.81 250.98,23.81 251.01,23.81 251.06,23.82 251.11,23.83 251.14,23.85 252.09,23.85 252.09,23.55 250.44,23.55 250.44,17.6 251.46,16.59 255.65,16.59 255.65,14.94 253.36,14.94 253.36,14.3 247.65,14.3 247.65,16.12 253.53,16.12 253.53,15.28 253.53,15.26 253.54,15.22 253.56,15.19 253.58,15.15 253.61,15.13 253.65,15.11 253.69,15.1 253.71,15.1 254.34,15.1 254.36,15.1 254.4,15.11 254.44,15.13 254.47,15.15 254.49,15.19 254.51,15.22 254.52,15.26 254.52,15.28 254.52,16.12 254.52,16.14 254.51,16.18 254.49,16.21 254.47,16.25 254.44,16.27 254.4,16.29 254.36,16.3 254.34,16.3 253.71,16.3 253.69,16.3 253.65,16.29 253.61,16.27 253.58,16.25 253.56,16.21 253.54,16.18 253.53,16.14 253.53,16.12 247.65,16.12 247.65,25.17 248.97,25.17
+12V on TOP (solid shape): outline of 223 points within 34.8,4.9 44.32,18.62
+12V on TOP: 34.8,18.49 34.8,37.54 75.31,37.54 76.07,36.78 77.98,36.78 77.98,34.24 76.2,32.46 64.13,32.46 61.47,29.8 61.47,18.49
+12V on BOTTOM: 34.8,29.03 221.22,29.05 233.04,17.22 251.46,17.22 253.36,15.32 253.36,13.54 221.36,13.54 216.41,18.49 49.78,18.49 46.73,15.45 46.73,3.51 45.21,1.98 34.8,1.98 ; 2 cut-outs
+15V on TOP (solid shape): 265.63,17.99 261.34,17.99 261.34,20.22 265.63,20.22
+15V on TOP (solid shape): 265.63,15.76 261.34,15.76 261.34,17.99 265.63,17.99
+15V on TOP (solid shape): 266.65,14.94 261.24,14.94 261.24,20.83 263.78,20.83 263.78,23.24 266.65,23.24
+15V on TOP: 266.7,11.51 255.27,11.51 255.27,14.81 261.24,14.81 261.24,15.06 266.7,15.06
+15V on BOTTOM: 20.95,33.35 20.95,31.57 225.8,31.57 226.95,30.43 234.31,30.43 237.3,27.45 242.12,27.45 253.87,15.7 253.87,11 252.35,9.48 222.38,9.48 222.38,3.13 258.44,3.13 258.44,9.48 260.48,11.51 266.7,11.51 266.7,15.95 266.32,16.33 257.81,16.33 240.79,33.35
+15V on BOTTOM: 21.46,31.57 20.45,31.57 15.37,26.49 9.9,26.49 6.98,29.42 6.98,32.59 10.03,32.59 10.41,32.21 10.41,29.67 14.73,29.67 18.41,33.35 21.46,33.35
-15V on TOP (solid shape): 244.35,21.67 245.49,21.67 245.49,17.48 240.92,17.48 240.92,21.9 237.18,21.9 237.18,23.41 240.35,23.41 240.35,22.26 240.35,22.24 240.36,22.2 240.37,22.17 240.4,22.13 240.43,22.11 240.47,22.09 240.51,22.08 240.53,22.08 242.33,22.08 242.35,22.08 242.39,22.09 242.42,22.11 242.45,22.13 242.48,22.17 242.49,22.2 242.5,22.24 242.5,22.26 242.5,23.41 242.5,23.43 242.49,23.47 242.48,23.51 242.45,23.54 242.42,23.56 242.39,23.58 242.35,23.59 242.33,23.59 240.53,23.59 240.51,23.59 240.47,23.58 240.43,23.56 240.4,23.54 240.37,23.51 240.36,23.47 240.35,23.43 240.35,23.41 237.18,23.41 237.18,23.88 244.35,23.88
-15V on TOP: 222.38,9.48 237.62,9.48 237.62,14.3 240.92,17.6 245.49,17.6 245.49,9.48 258.44,9.48 258.44,3.13 222.38,3.13
-15V on BOTTOM: 21.21,31.19 21.21,29.42 223.65,29.42 235.58,17.48 245.49,17.48 245.49,21.67 240.79,21.67 239.14,20.02 236.35,20.02 225.17,31.19
-15V on BOTTOM: 6.22,31.83 5.59,32.46 3.3,32.46 3.3,28.91 8.13,24.08 17.52,24.08 22.86,29.42 22.86,31.19 20.7,31.19 15.62,26.11 9.65,26.11 6.22,29.54
VIN on TOP (solid shape): 29.04,4.99 24.75,4.99 24.75,7.22 29.04,7.22
VIN on TOP (solid shape): 29.04,2.76 24.75,2.76 24.75,4.99 29.04,4.99
VIN on TOP: 9.9,12.27 17.78,12.27 22.1,7.95 25.4,7.95 25.4,9.6 26.92,9.6 26.92,7.95 29.21,7.95 29.21,1.98 9.9,1.98
(no net) on TOP: 250.62,23.37 252.22,23.37 252.22,21.8 255.55,21.8 255.55,23.37 256.72,23.37 256.72,16.72 251.71,16.72 250.62,17.81
(no net) on TOP: 229.54,27.56 231.14,27.56 231.14,25.99 234.47,25.99 234.47,27.56 235.63,27.56 235.63,21.97 231.62,21.97 231.62,24.18 229.54,24.18
(no net) on TOP: 231.24,26.09 231.24,33.76 228.14,33.76 228.14,30.84 226.52,30.84 226.52,34.52 226.54,34.55 234.34,34.55 234.34,31.5 239.72,31.5 240.16,31.07 240.16,29.24 239.34,29.24 239.34,27.92 237.64,27.92 237.64,30.51 236.24,30.51 235.48,29.75 234.44,29.75 234.34,29.64 234.34,26.09
(no net) on TOP: 226.95,30.66 229.41,30.66 229.61,30.46 229.61,29.97 230.05,29.54 231.01,29.54 231.01,29.23 229.75,29.23 229.39,29.59 226.95,29.59
(no net) on TOP: 34.8,13.84 34.8,18.62 44.32,18.62 44.32,4.9 40.51,4.9 40.51,13.84
(no net) on TOP: 231.29,23.78 231.29,21.67 234.59,21.67 234.59,19.99 229.54,19.99 229.54,23.78
(no net) on TOP: 252.32,21.9 252.32,29.57 249.05,29.57 249.05,26.65 247.27,26.65 247.27,30 247.62,30.36 255.42,30.36 255.42,27.31 261.72,27.31 261.72,25.05 260.43,25.05 260.43,23.73 258.72,23.73 258.72,26.32 257.33,26.32 256.56,25.56 255.52,25.56 255.42,25.45 255.42,21.9
(no net) on TOP: 234.57,29.54 235.69,29.54 236.37,30.23 237.41,30.23 237.41,29.21 235.91,29.21 235.89,29.24 234.57,29.24
(no net) on TOP: 231.01,27.74 231.01,28.04 228.09,28.04 228.09,29.37 226.57,29.37 226.57,25.83 224.03,25.83 223.65,25.45 223.65,20.5 226.57,17.58 240.69,17.58 240.69,21.69 237.18,21.69 237.18,19.66 226.41,19.66 226.26,19.81 226.26,23.19 229.36,23.19 229.36,27.74
(no net) on TOP: 230,31.73 230,30.36 230.1,30.25 230.1,29.75 231.01,29.75 231.01,31.73
(no net) on TOP: 258.44,24.77 257.02,24.77 256.92,24.87 255.65,24.87 255.65,24.56 256.67,24.56 257.48,23.75 258.44,23.75
(no net) on TOP: 263.45,21.31 263.45,23.14 258.82,23.14 258.82,21.59 259.1,21.31
(no net) on TOP: 29.4,6.39 30.92,6.39 30.92,7.91 33.59,7.91 33.59,3.59 32.19,3.59 32.19,2.2 29.4,2.2
(no net) on TOP: 252.09,23.55 252.09,23.85 249.17,23.85 249.17,25.17 247.65,25.17 247.65,14.3 253.36,14.3 253.36,14.94 255.65,14.94 255.65,16.59 251.46,16.59 250.44,17.6 250.44,23.55
(no net) on TOP: 260.96,16.59 260.96,14.94 255.8,14.94 255.8,16.59
(no net) on TOP: 255.65,25.35 256.77,25.35 257.45,26.04 258.49,26.04 258.49,25.02 257,25.02 256.97,25.05 255.65,25.05
(no net) on TOP: 226.49,19.94 226.49,22.96 228.8,22.96 228.8,19.94
(no net) on TOP: 257.07,23.14 258.6,23.14 258.6,21.41 259.18,20.83 260.96,20.83 260.96,16.77 257.07,16.77
(no net) on TOP: 226.34,26.09 226.34,28.02 223.6,28.02 223.6,26.09
(no net) on TOP: 237.36,28.96 235.94,28.96 235.84,29.06 234.57,29.06 234.57,28.76 235.63,28.76 236.45,27.94 237.36,27.94
(no net) on TOP: 33.72,2.07 33.72,8.69 35.09,10.07 39.94,10.07 39.94,2.07
(no net) on TOP: 247.42,21.9 247.42,23.83 244.68,23.83 244.68,21.9
(no net) on TOP: 251.08,27.54 251.08,26.16 251.18,26.06 251.18,25.56 252.09,25.56 252.09,27.54
(no net) on TOP: 242.87,24.77 242.87,27.33 235.99,27.33 235.99,24.77
(no net) on TOP: 228.34,31.27 228.34,33.61 229.49,33.61 229.49,31.27
(no net) on TOP: 231.01,28.55 230.05,28.55 229.26,29.34 228.5,29.34 228.5,28.22 231.01,28.22
(no net) on TOP: 261.24,20.83 263.78,20.83 263.78,23.24 266.65,23.24 266.65,14.94 261.24,14.94
(no net) on TOP: 237.18,21.9 237.18,23.88 244.35,23.88 244.35,21.67 245.49,21.67 245.49,17.48 240.92,17.48 240.92,21.9
(no net) on GND1: 231.24,30.2 231.24,27.64 226.64,27.64 226.26,28.02 223.6,28.02 223.6,26.09 230.66,26.09 227.53,22.96 226.49,22.96 226.49,19.94 228.8,19.94 228.8,21.97 232.92,26.09 235.41,26.09 236.73,24.77 239.29,24.77 239.29,27.33 234.34,27.33 234.34,30.2
(no net) on GND1: 252.32,26.01 252.32,23.45 247.73,23.45 247.34,23.83 244.68,23.83 244.68,21.9 258.42,21.9 259,21.31 260.37,21.31 260.37,23.45 255.42,23.45 255.42,26.01
0 on TOP (solid shape): 226.34,26.09 223.6,26.09 223.6,28.02 226.34,28.02
0 on TOP (solid shape): 228.8,19.94 226.49,19.94 226.49,22.96 228.8,22.96
0 on TOP (solid shape): 247.42,21.9 244.68,21.9 244.68,23.83 247.42,23.83
0 on TOP (solid shape): 263.45,21.31 259.1,21.31 258.82,21.59 258.82,23.14 263.45,23.14
0 on TOP (solid shape): 242.87,24.77 235.99,24.77 235.99,26.41 240.35,26.41 240.35,25.26 240.35,25.24 240.36,25.2 240.37,25.17 240.4,25.13 240.43,25.11 240.47,25.09 240.51,25.08 240.53,25.08 242.33,25.08 242.35,25.08 242.39,25.09 242.42,25.11 242.45,25.13 242.48,25.17 242.49,25.2 242.5,25.24 242.5,25.26 242.5,26.41 242.5,26.43 242.49,26.47 242.48,26.51 242.45,26.54 242.42,26.56 242.39,26.58 242.35,26.59 242.33,26.59 240.53,26.59 240.51,26.59 240.47,26.58 240.43,26.56 240.4,26.54 240.37,26.51 240.36,26.47 240.35,26.43 240.35,26.41 235.99,26.41 235.99,27.33 242.87,27.33
0 on TOP (solid shape): outline of 95 points within 226.52,26.17 240.16,34.55
0 on TOP (solid shape): outline of 110 points within 247.27,21.97 261.72,30.13
0 on GND1 (solid shape): 255.42,23.45 260.37,23.45 260.37,21.31 259,21.31 258.42,21.9 244.68,21.9 244.68,23.83 247.34,23.83 247.73,23.45 252.32,23.45 252.32,26.01 255.42,26.01
0 on GND1 (solid shape): 234.34,27.33 239.29,27.33 239.29,24.77 236.73,24.77 235.41,26.09 232.92,26.09 228.8,21.97 228.8,19.94 226.49,19.94 226.49,22.96 227.53,22.96 230.57,26 230.58,26.06 230.53,26.09 223.6,26.09 223.6,28.02 226.26,28.02 226.64,27.64 231.24,27.64 231.24,30.2 234.34,30.2
0 on GND1: 24.64,53.16 26.43,53.91 27.18,55.7 27.18,68.4 24.64,68.4 24.64,72.47 27.18,72.47 27.18,91.52 26.43,93.32 24.64,94.06 16.67,94.06 14.87,94.8 14.13,96.6 14.13,100 15.78,103.97 19.75,105.62 194.44,105.62 196.23,104.87 196.98,103.08 196.98,60.19 197.17,59.21 197.72,58.39 201.19,54.92 202.01,54.37 202.98,54.18 219.29,54.18 220.26,53.99 221.09,53.44 242.71,31.81 243.54,31.26 244.51,31.07 267.08,31.07 268.88,30.32 269.62,28.53 269.62,6 267.97,2.03 264,0.38 225.54,0.38 221.57,2.03 219.92,6 219.92,12 218.05,16.51 213.54,18.38 56.46,18.38 51.95,16.51 50.08,12 50.08,6 48.43,2.03 44.46,0.38 2.54,0.38 1.01,1.01 0.38,2.54 0.38,50.62 1.12,52.42 2.92,53.16 ; 2 cut-outs
0 on GND2: 24.64,53.16 26.43,53.91 27.18,55.7 27.18,68.4 24.64,68.4 24.64,72.47 27.18,72.47 27.18,91.52 26.43,93.32 24.64,94.06 16.67,94.06 14.87,94.8 14.13,96.6 14.13,100 15.78,103.97 19.75,105.62 194.44,105.62 196.23,104.87 196.98,103.08 196.98,60.19 197.17,59.21 197.72,58.39 201.19,54.92 202.01,54.37 202.98,54.18 219.29,54.18 220.26,53.99 221.09,53.44 242.71,31.81 243.54,31.26 244.51,31.07 267.08,31.07 268.88,30.32 269.62,28.53 269.62,6 267.97,2.03 264,0.38 225.54,0.38 221.57,2.03 219.92,6 219.92,12 218.05,16.51 213.54,18.38 56.46,18.38 51.95,16.51 50.08,12 50.08,6 48.43,2.03 44.46,0.38 2.54,0.38 1.01,1.01 0.38,2.54 0.38,50.62 1.12,52.42 2.92,53.16
1 on GND1, GND2: 18.67,90.68 20.46,89.94 21.21,88.14 21.21,60.2 20.46,58.4 18.67,57.66 2.92,57.66 1.12,58.4 0.38,60.2 0.38,88.14 1.12,89.94 2.92,90.68
N97055 on TOP (solid shape): outline of 125 points within 257.07,16.77 260.96,23.14
N147166 on TOP (solid shape): outline of 241 points within 29.4,2.2 33.59,7.91
N148540 on TOP (solid shape): 38.24,4.99 33.95,4.99 33.95,7.22 38.24,7.22
N148540 on TOP (solid shape): 38.24,2.76 33.95,2.76 33.95,4.99 38.24,4.99
N148540 on TOP (solid shape): outline of 204 points within 33.72,2.07 39.94,10.07
N200782 on TOP (solid shape): 257.02,24.77 258.44,24.77 258.44,23.76 257.51,23.76 256.85,24.42 256.8,24.46 256.74,24.49 256.67,24.56 255.65,24.56 255.65,24.87 256.92,24.87
N204184 on TOP (solid shape): 256.72,16.72 255.83,16.72 255.83,16.77 251.66,16.77 250.62,17.81 250.62,23.37 252.22,23.37 252.22,21.8 255.55,21.8 255.55,23.37 256.72,23.37
N204300 on TOP (solid shape): 252.09,25.56 251.18,25.56 251.18,26.06 251.08,26.16 251.08,27.54 252.09,27.54
N204715 on TOP (solid shape): 258.49,25.02 257.02,25.02 256.99,25.05 255.65,25.05 255.65,25.35 256.77,25.35 257.45,26.04 258.49,26.04
N205443 on TOP (solid shape): outline of 113 points within 255.83,14.94 260.96,16.59
N208883 on TOP (solid shape): 235.63,21.97 231.62,21.97 231.62,24.18 229.54,24.18 229.54,27.56 231.14,27.56 231.14,25.99 234.47,25.99 234.47,27.56 235.63,27.56
N209249 on TOP (solid shape): 231.01,29.75 230.1,29.75 230.1,30.25 230,30.36 230,31.73 231.01,31.73
N209309 on TOP (solid shape): 230.05,28.55 231.01,28.55 231.01,28.22 230.1,28.22 230.08,28.22 228.5,28.22 228.5,29.34 229.26,29.34
N209373 on TOP (solid shape): 235.94,28.96 237.36,28.96 237.36,27.95 236.44,27.95 235.63,28.76 234.57,28.76 234.57,29.06 235.84,29.06
N209381 on TOP (solid shape): 229.61,30.46 229.61,29.97 230.05,29.54 231.01,29.54 231.01,29.23 229.75,29.23 229.63,29.35 229.63,29.35 229.59,29.41 229.54,29.44 229.53,29.45 229.39,29.59 226.95,29.59 226.95,30.66 229.41,30.66
N209421 on TOP (solid shape): 237.41,29.21 235.94,29.21 235.91,29.24 234.57,29.24 234.57,29.54 235.69,29.54 236.37,30.23 237.41,30.23
N209493 on TOP (solid shape): 229.49,31.27 228.34,31.27 228.34,33.58 229.49,33.58
N213371 on TOP (solid shape): 231.29,21.67 234.59,21.67 234.59,19.99 229.54,19.99 229.54,23.01 229.54,23.01 229.54,23.78 231.29,23.78

## Text on the board
User.Comments: CR_INPUT-PROTECTION_1 | CR_ONE-SHOT_1 | CR_CURRENT-SENSE_1 | CR_LT3581-BOOST_1 | CR_DIFFERENTIAL-FILTER_5 | CR_VOLTAGE-SENSE_4 | CR_HV-RESISTORSBA_3 | CR_HV-RESISTORSTA_6 | CR_HV-RESISTORS_1 | CR_INVERTING-SMPS_1 | CR_SEPIC_1 | CR_MOSFET-PULLDOWN_1 | CR_MOSFET-PULLDOWN_2 | CR_DIFFERENTIAL-FILTER_3 | CR_TEMPARTURE-FILTER_3 | CR_CURRENT-SENSE_3 | Connector Housing
Ref Des/Silkscreen Top: Controller V1.2 | + | +5V | GD-U | +3V3 | GD-V | GD-W | CAUTION | VOLTAGE | I-U | HIGH | -15V | VDC- | VDC+ | I-V | VC- | VC+ | VB- | VB+ | VA- | VA+ | +15V | I-W | AUX | CAN | POWER | 12V
XSECTION_CHART: *  SURFACE - 0 MIL | L1 TOP CONDUCTOR - 1.4 MIL | *  DIELECTRIC - 8 MIL | L2 GND1 CONDUCTOR - 1.4 MIL | L3 LAYER3 CONDUCTOR - 1.4 MIL | *  DIELECTRIC - 21.6 MIL | L4 PWR CONDUCTOR - 1.4 MIL | L5 GND2 CONDUCTOR - 1.4 MIL | L6 BOTTOM CONDUCTOR - 1.4 MIL | DESIGN CROSS SECTION CHART | ___________________________ | TOTAL THICKNESS 62 MIL | 1-6
DISPLAY_TOP: FIGURE | FINISHED_SIZE | 13.0 | 28.0 | 36.0 | 45.0 | 47.24 | 50.0 | 70.0 | 85.0 | 110.0 | 130.0 | 170.0 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILS | PLATED | NON-PLATED | QTY | 503 | 26 | 9 | 168 | 6 | 3 | 2 | 7
